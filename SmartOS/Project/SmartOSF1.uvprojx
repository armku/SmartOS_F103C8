# Keil uVision project SmartOSF1.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOS_F1D +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1,DEBUG
  c misc: --cpp11
  c include: ..\..\SmartOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: ACZero.cpp Alarm.cpp AnChe.cpp AT.cpp BlinkPort.cpp Button.cpp Button_GrayLevel.cpp Button_magnetic.cpp CommandPort.cpp Dimmer.cpp FlushPort.cpp IR.cpp IRcoding.cpp PowerUps.cpp PulsePort.cpp Raster.cpp Sensor.cpp Sound.cpp
  group Board
    ../Board/: AP0103.cpp AP0104.cpp AP0801.cpp AP0802.cpp AP0803.cpp BaseBoard.cpp Esp8266Module.cpp GsmModule.cpp IOK026X.cpp IOK027X.cpp IOK0612.cpp LinkBoard.cpp NH3_0317.cpp Pandora.cpp TokenBoard.cpp W5500Module.cpp
  group Core
    ../Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp Delegate.cpp Dictionary.cpp Environment.cpp List.cpp Queue.cpp Random.cpp Stream.cpp String.cpp TimeSpan.cpp Type.cpp Version.cpp
  group Device
    ../Device/: ADC.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Port.cpp Power.cpp Proxy.cpp ProxyConfig.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp UTPort.cpp WatchDog.cpp
  group Drivers
    ../Drivers/: 74HC165.cpp 74HC165Monitor.cpp A67.cpp AT24CXX.cpp AT45DB.cpp BH1750.cpp BufferPort.cpp DHT11.cpp Enc28j60.cpp GSM07.cpp HMI.cpp HX711.cpp JTW8953.cpp NRF24L01.cpp PMS5003.cpp SHT30.cpp ShunCom.cpp Sim900A.cpp UBlox.cpp W5500.cpp
  group Esp8266
    ../Drivers/Esp8266/: Esp8266.cpp EspSocket.cpp EspTcp.cpp EspUdp.cpp WaitExpect.cpp
  group Kernel
    ../Kernel/: Heap.cpp Interrupt.cpp Sys.cpp Task.cpp Thread.cpp Time.cpp WaitHandle.cpp
  group Link
    ../Link/: LinkClient.cpp LinkConfig.cpp LinkMessage.cpp TinyLink.cpp
  group Message
    ../Message/: Api.cpp BinaryPair.cpp Controller.cpp DataStore.cpp GatherConfig.cpp HistoryStore.cpp Json.cpp Message.cpp MessageBase.cpp Pair.cpp ProxyFactory.cpp UTPacket.cpp WeakStore.cpp
  group Net
    ../Net/: Blu40.cpp Dhcp.cpp DNS.cpp HttpClient.cpp IPAddress.cpp IPEndPoint.cpp ITransport.cpp MacAddress.cpp NetUri.cpp NetworkInterface.cpp Socket.cpp Zigbee.cpp
  group Security
    ../Security/: AES.cpp Crc.cpp Crc16.cpp MD5.cpp RC4.cpp RC6.cpp RSA.cpp
  group Storage
    ../Storage/: Storage.cpp
  group Test
    ../Test/: ADCTest.cpp ArrayTest.cpp AT45DBTest.cpp BufferTest.cpp CrcTest.cpp DateTimeTest.cpp DictionaryTest.cpp EthernetTest.cpp FlashTest.cpp InvokeTest.cpp IRTest.cpp JsonTest.cpp ListTest.cpp MessageTest.cpp NRF24L01Test.cpp PulsePortTest.cpp SerialTest.cpp StringTest.cpp ThreadTest.cpp TimerTest.cpp
  group TinyIP
    ../TinyIP/: Arp.cpp Icmp.cpp Tcp.cpp TinyIP.cpp Udp.cpp
  group TinyNet
    ../TinyNet/: DataMessage.cpp JoinMessage.cpp PingMessage.cpp Tiny.cpp TinyClient.cpp TinyConfig.cpp TinyController.cpp TinyMessage.cpp TinyServer.cpp
  group TokenNet
    ../TokenNet/: Device.cpp DeviceBody.cpp DeviceMessage.cpp DevicesManagement.cpp ErrorMessage.cpp Gateway.cpp HelloMessage.cpp LoginMessage.cpp RegisterMessage.cpp TokenClient.cpp TokenConfig.cpp TokenController.cpp TokenDataMessage.cpp TokenDevice.cpp TokenMessage.cpp TokenPingMessage.cpp TokenSession.cpp
  group Boot
    ../: BootConfig.cpp Config.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
