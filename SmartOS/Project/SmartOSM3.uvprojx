# Keil uVision project SmartOSM3.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOS_x86D +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1,DEBUG
  c misc: --cpp11
  c include: ..\..\SmartOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SmartOS_M3
    ../Platform/CortexM/: Interrupt.cpp Port.cpp Runtime.cpp SerialPort.cpp Sys.cpp Thread.cpp Time.cpp
  group M3
    ../Platform/STM32F1/: ADC.cpp Boot_F1.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Interrupt.cpp Port.cpp Power.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
