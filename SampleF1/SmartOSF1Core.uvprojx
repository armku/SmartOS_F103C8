# Keil uVision project SmartOSF1Core.uvprojx, settings and files
target SmartOSF1_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOSF1_Debug
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F1,DEBUG,USE_FULL_ASSERT
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\Device;..\SmartOS\Kernel;..\LibF1\inc;..\LibF1\CMSIS;..\SmartOS\Platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.cpp
  group App
    ../SmartOS/App/: BlinkPort.cpp
  group Core
    ../SmartOS/Core/: Array.cpp Buffer.cpp ByteArray.cpp DateTime.cpp Delegate.cpp Dictionary.cpp Environment.cpp List.cpp Queue.cpp Random.cpp Stream.cpp String.cpp TimeSpan.cpp Type.cpp Version.cpp
  group Device
    ../SmartOS/Device/: ADC.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Port.cpp Power.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp
  group Driver
    ../SmartOS/Drivers/: AT24CXX.cpp
    ../SmartOS/Drivers/I2C/NPA/: NPA_700B_015A.cpp
  group Kernel
    ../SmartOS/Kernel/: Heap.cpp Interrupt.cpp Sys.cpp Task.cpp Thread.cpp Time.cpp WaitHandle.cpp
  group Net
    ../SmartOS/Net/: ITransport.cpp
  group Security
    ../SmartOS/Security/: AES.cpp Crc.cpp Crc16.cpp MD5.cpp RC4.cpp RC6.cpp RSA.cpp
  group Storage
    ../SmartOS/Storage/: Storage.cpp
  group Boot
    ../SmartOS/: BootConfig.cpp Config.cpp
  group STM32F1
    ../SmartOS/Platform/STM32F1/: ADC.cpp Boot_F1.cpp CAN.cpp DAC.cpp DMA.cpp Flash.cpp I2C.cpp Interrupt.cpp Port.cpp Power.cpp Pwm.cpp RTC.cpp SerialPort.cpp Spi.cpp Timer.cpp WatchDog.cpp startup_stm32f10x.s
  group PlatformCortexM
    ../SmartOS/Platform/CortexM/: Interrupt.cpp Port.cpp Runtime.cpp SerialPort.cpp Sys.cpp Thread.cpp Time.cpp
  group LibF1
    ../LibF1/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CorexM
    ../LibF1/CMSIS/: core_cm3.c
  group Modbus
    ../SmartOS/Modbus/: Master.cpp Modbus.cpp Slave.cpp
target SmartOSF1_RTM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOSF1_RTM
  AfterMake: XScript.exe Build.cs /NoLogo /NoTime /NoStop /Hide
  c flags: Optim=4 OneElfS=1
  c define: STM32F1
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\Device;..\SmartOS\Kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target SmartOSF1_Lib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: SmartOS_F1D (library)
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F1,DEBUG,USE_FULL_ASSERT
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\Device;..\SmartOS\Kernel;..\LibF1\inc;..\LibF1\CMSIS;..\SmartOS\Platform;..\..\LibF1\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
